options:
  parameters:
    generate_options: qt_gui
    id: practica
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0, 0, 0)
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):

          def __init__( self ): # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name ="e_Acum", # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              
          def work (self , input_items, output_items):
              x = input_items [0] # Senial de entrada .
              y0 = output_items [0] # Senial acumulada
              
              y0[:] = np.cumsum(x)
              
              return len(y)
    comment: Acumulador
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk (gr. sync_block ):

          def __init__ ( self ) : # only default arguments here
              gr. sync_block . __init__ (
                  self ,
                  name ='e_Diff', # will show up in GRC
                  in_sig =[ np. float32 ],
                  out_sig =[ np. float32 ]
              
              self . acum_anterior = 0
              )
              
          def work (self , input_items , output_items ):
              x = input_items [0] # Senial de entrada .
              y0 = output_items [0] # Senial acumulada diferencial

              N = len (x)
              diff = np. cumsum (x) - self . acum_anterior
              self . acum_anterior = diff [N -1]
              y0 [:] = diff
              return len (y)
    comment: DIferenciador
    example_param: '1.0'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk (gr. sync_block ):

          def __init__ ( self ) : # only default arguments here
              gr. sync_block . __init__ (
                  self ,
                  name =’ Promedios_de_tiempos ’, # will show up in GRC
                  in_sig =[ np. float32 ],
                  out_sig =[ np. float32 ,np. float32 ,np. float32 ,np. float32 ,np. float32 ]
              )   
              self . acum_anterior = 0
              self . Ntotales = 0
              self . acum_anterior1 = 0
              self . acum_anterior2 = 0

          def work (self , input_items , output_items ):
              x = input_items [0] # Senial de entrada .
              y0 = output_items [0] # Promedio de la senial
              y1 = output_items [1] # Media de la senial
              y2 = output_items [2] # RMS de la senial
              y3 = output_items [3] # Potencia promedio de la senial
              y4 = output_items [4] # Desviacion estandar de la senial

              # Calculo del promedio
              N = len (x)
              self . Ntotales = self . Ntotales + N
              acumulado = self . acum_anterior + np. cumsum (x)
              self . acum_anterior = acumulado [N -1]
              y0 [:]= acumulado / self . Ntotales

              # Calculo de la media cuadratica
              x2=np. multiply (x,x)
              acumulado1 = self . acum_anterior1 + np. cumsum (x2)
              self . acum_anterior1 = acumulado [N -1]
              y1 [:] = acumulado1 / self . Ntotales

              # Calculo de la RMS
              y2 [:] = np. sqrt (y1)

              # Calculo de la potencia promedio
              y3 [:] = np. multiply (y2 ,y2)

              # Calculo de la desviacion estandar
              x3 = np. multiply (x-y0 ,x-y0)
              acumulado2 = self . acum_anterior2 + np. cumsum (x3)
              self . acum_anterior2 = acumulado2 [N -1]
              y4 [:] = np. sqrt ( acumulado2 / self . Ntotales )

              return len (x)
    comment: Promedio de tiempo
    example_param: '1.0'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_vector_source_x_0, '0', epy_block_1, '0']
- [blocks_vector_source_x_0, '0', epy_block_2, '0']
- [epy_block_1, '0', qtgui_sink_x_0, '0']
- [epy_block_2, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
